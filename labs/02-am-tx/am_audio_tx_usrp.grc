options:
  parameters:
    description: AM audio transmitter via USRP B200mini at 80 MHz
    generate_options: no_gui
    id: am_audio_tx_usrp
    output_language: python
    run_options: run
    title: AM Audio TX (USRP)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '80000000'
  states: {}
- name: carrier_level
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: assets/message_audio.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Stereo to mono
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Gain (0.5 for mono mix)
    const: '0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: 'DC offset: 1 + message'
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: carrier_level
    comment: AM carrier (baseband)
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: 'AM mod: carrier * (1+msg)'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 48k -> 2M
    decim: audio_rate
    fbw: '0.4'
    interp: samp_rate
    type: ccc
  states: {}
- name: soapy_uhd_sink_0
  id: soapy_custom_sink
  parameters:
    center_freq: center_freq
    comment: USRP B200mini via SoapySDR
    dev_args: driver=uhd
    samp_rate: samp_rate
    type: fc32
    gain0: '50'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', soapy_uhd_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
