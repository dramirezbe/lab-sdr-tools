options:
  parameters:
    author: lab-sdr-tools
    comment: Wideband FM receiver using RTL-SDR via SoapySDR
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver (RTL-SDR)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 96.9e6
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    gain: '40'
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate / audio_rate)
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    name: '"Spectrum"'
    type: complex
    wintype: window.WIN_BLACKMAN_HARRIS
    ymax: '0'
    ymin: '-120'
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
