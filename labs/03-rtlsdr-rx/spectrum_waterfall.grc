options:
  parameters:
    author: lab-sdr-tools
    comment: Spectrum analyzer with waterfall using RTL-SDR
    generate_options: qt_gui
    id: spectrum_waterfall
    output_language: python
    title: Spectrum Waterfall (RTL-SDR)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    gain: '40'
    type: fc32
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,1
    name: '"Spectrum"'
    type: complex
    update_time: '0.05'
    wintype: window.WIN_BLACKMAN_HARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    int_max: '0'
    int_min: '-120'
    name: '"Waterfall"'
    type: complex
    update_time: '0.05'
    wintype: window.WIN_BLACKMAN_HARRIS
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
