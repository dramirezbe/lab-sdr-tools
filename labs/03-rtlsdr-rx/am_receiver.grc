options:
  parameters:
    author: lab-sdr-tools
    comment: AM receiver using RTL-SDR — envelope detection
    generate_options: qt_gui
    id: am_receiver
    output_language: python
    title: AM Receiver (RTL-SDR)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    gain: '40'
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: channel_width
    decim: int(samp_rate / audio_rate)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: channel_width * 0.5
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '0.5'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    name: '"Spectrum"'
    type: complex
    wintype: window.WIN_BLACKMAN_HARRIS
    ymax: '0'
    ymin: '-120'
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [analog_agc_xx_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
